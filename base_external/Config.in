## base_external/package/tempsens/Config.in
```kconfig
config BR2_PACKAGE_TEMPSENS
	bool "tempsens"
	help
	  Read from tempsens wiht i2c
```
